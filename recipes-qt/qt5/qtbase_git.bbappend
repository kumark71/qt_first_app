PACKAGECONFIG:append = " accessibility eglfs linuxfb gles2 tslib"
